options:
  parameters:
    author: Javier Acevedo
    category: Custom
    copyright: MIT
    generate_options: qt_gui
    id: data_packing
    output_language: python
    title: Data package test
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '256'
    min: '255'
    num_samps: '10'
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: packetsingle
    type: byte
  states: {state: disabled}
- name: blocks_file_sink_1
  id: blocks_file_sink
  parameters:
    file: packet2
    type: byte
  states: {state: disabled}
- name: blocks_file_sink_1_0
  id: blocks_file_sink
  parameters:
    file: packetsingleout
    type: byte
  states: {state: disabled}
- name: blocks_file_sink_2
  id: blocks_file_sink
  parameters:
    append: 'True'
    file: floriandatei
    type: byte
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/supersonic/GitHub/Post-Shannon-SDR/Examples/BPSK/testFiles/test_file
    repeat: 'False'
    type: byte
  states: {state: disabled}
- name: blocks_file_source_0_0
  id: blocks_file_source
  parameters:
    file: /home/supersonic/GitHub/Post-Shannon-SDR/Examples/BPSK/testFiles/test_file
    repeat: 'False'
    type: byte
  states: {state: disabled}
- name: blocks_file_source_0_1
  id: blocks_file_source
  parameters:
    file: /home/supersonic/GitHub/Post-Shannon-SDR/Examples/BPSK/Labor/packetsingle
    repeat: 'False'
    type: byte
  states: {state: disabled}
- name: blocks_packed_to_unpacked_xx_0
  id: blocks_packed_to_unpacked_xx
  parameters:
    bits_per_chunk: '8'
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {state: disabled}
- name: blocks_packed_to_unpacked_xx_0_0
  id: blocks_packed_to_unpacked_xx
  parameters:
    bits_per_chunk: '1'
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {state: disabled}
- name: blocks_packed_to_unpacked_xx_0_1
  id: blocks_packed_to_unpacked_xx
  parameters:
    bits_per_chunk: '8'
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {state: disabled}
- name: blocks_unpacked_to_packed_xx_0
  id: blocks_unpacked_to_packed_xx
  parameters:
    bits_per_chunk: '8'
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {state: disabled}
- name: blocks_unpacked_to_packed_xx_0_0
  id: blocks_unpacked_to_packed_xx
  parameters:
    bits_per_chunk: '8'
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {state: disabled}
- name: blocks_unpacked_to_packed_xx_0_0_0
  id: blocks_unpacked_to_packed_xx
  parameters:
    bits_per_chunk: '1'
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {state: disabled}

connections:
- [analog_random_source_x_0, '0', blocks_file_sink_2, '0']
- [blocks_file_source_0, '0', blocks_packed_to_unpacked_xx_0, '0']
- [blocks_file_source_0, '0', blocks_unpacked_to_packed_xx_0, '0']
- [blocks_file_source_0_0, '0', blocks_packed_to_unpacked_xx_0_0, '0']
- [blocks_file_source_0_1, '0', blocks_packed_to_unpacked_xx_0_1, '0']
- [blocks_file_source_0_1, '0', blocks_unpacked_to_packed_xx_0_0_0, '0']
- [blocks_packed_to_unpacked_xx_0, '0', blocks_file_sink_1, '0']
- [blocks_packed_to_unpacked_xx_0_0, '0', blocks_file_sink_0, '0']
- [blocks_packed_to_unpacked_xx_0_1, '0', blocks_file_sink_1_0, '0']
- [blocks_unpacked_to_packed_xx_0, '0', blocks_file_sink_1, '0']
- [blocks_unpacked_to_packed_xx_0_0, '0', blocks_file_sink_1_0, '0']
- [blocks_unpacked_to_packed_xx_0_0_0, '0', blocks_unpacked_to_packed_xx_0_0, '0']

metadata:
  file_format: 1
