options:
  parameters:
    author: Javier Acevedo
    category: Custom
    copyright: MIT
    generate_options: qt_gui
    id: ofdm_mod
    output_language: python
  states: {}

blocks:
- name: delay_tx
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,2,1,2
    orient: Qt.Horizontal
    start: '5'
    step: '1'
    stop: '100'
    value: '25'
  states: {state: disabled}
- name: excess_bw
  id: variable
  parameters:
    value: '0.350'
  states: {}
- name: fft_len
  id: variable
  parameters:
    value: '64'
  states: {}
- name: loop_order
  id: variable
  parameters:
    value: '2'
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '4'
  states: {}
- name: noise
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,1
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '100'
    value: '50'
  states: {}
- name: ntaps
  id: variable
  parameters:
    value: '15'
  states: {}
- name: packet_len
  id: variable
  parameters:
    value: '64'
  states: {}
- name: phase_bw
  id: variable
  parameters:
    value: '62.8e-3'
  states: {}
- name: qam_const
  id: variable_constellation
  parameters:
    precision: '8'
    type: 16qam
  states: {}
- name: rrc_taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(nfilts, nfilts, 1.0/float(sps), 0.35, 45*nfilts)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 32e3
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: taps
  id: variable
  parameters:
    value: '[1.0, 0.25-0.25j, 0.50 + 0.10j, -0.3 + 0.2j]'
  states: {}
- name: tunning
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,1,1,1
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '100'
    value: '50'
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_1
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: delay_tx
    type: float
  states: {state: disabled}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/supersonic/GitHub/Post-Shannon-SDR/Examples/BPSK/testFiles/test_file_rx
    type: byte
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/supersonic/GitHub/Post-Shannon-SDR/Examples/BPSK/testFiles/test_file
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_packed_to_unpacked_xx_0
  id: blocks_packed_to_unpacked_xx
  parameters:
    bits_per_chunk: '1'
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {state: disabled}
- name: blocks_sub_xx_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {state: disabled}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {state: disabled}
- name: blocks_unpacked_to_packed_xx_0_0
  id: blocks_unpacked_to_packed_xx
  parameters:
    bits_per_chunk: '8'
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: blocks_unpacked_to_packed_xx_0_0_0
  id: blocks_unpacked_to_packed_xx
  parameters:
    bits_per_chunk: '1'
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: digital_cma_equalizer_cc_0
  id: digital_cma_equalizer_cc
  parameters:
    modulus: '1'
    mu: '0.01'
    num_taps: '15'
    sps: '16'
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: qam_const
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: '8'
    use_snr: 'True'
    w: phase_bw
  states: {}
- name: digital_diff_decoder_bb_0
  id: digital_diff_decoder_bb
  parameters:
    modulus: '2'
  states: {}
- name: digital_ofdm_carrier_allocator_cvc_0
  id: digital_ofdm_carrier_allocator_cvc
  parameters:
    fft_len: fft_len
    len_tag_key: '"packet_len"'
    occupied_carriers: ((-2, -1, 1, 3), (-3, -1, 1, 2))
    output_is_shifted: 'True'
    pilot_carriers: ((-3, 2), (-2, 3))
    pilot_symbols: ((-1, 1j), (1, -1j), (-1, 1j), (-1j, 1))
    sync_words: '[0., 0., 0., 0., 0., 0., 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., -1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., -1.41421356, 0., -1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 0., 0., 0., 0., 0.]'
  states: {}
- name: digital_ofdm_cyclic_prefixer_0
  id: digital_ofdm_cyclic_prefixer
  parameters:
    cp_len: '16'
    input_size: fft_len
    tagname: '"frame_len"'
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    gui_hint: 3,0,2,2
    name: Constallation Transmitter
    size: '1024'
    type: complex
  states: {}
- name: qtgui_const_sink_x_0_0
  id: qtgui_const_sink_x
  parameters:
    gui_hint: 3,2,2,2
    name: Constalletion Receiver
    size: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 5,0,1,4
    label1: Rx
    label2: Offset
    label3: Tx
    name: Input output signal
    nconnections: '3'
    size: '1024'
    srate: samp_rate
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 5,0,1,4
    label1: Rx
    name: Input output signal
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_2
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 1,0,1,4
    name: Transmitted Signal
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_2_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 2,0,1,4
    name: Received Signal
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: data
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: original_data
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: data
  states: {}
- name: virtual_source_2
  id: virtual_source
  parameters:
    stream_id: original_data
  states: {state: disabled}

connections:
- [blocks_char_to_float_0, '0', blocks_sub_xx_0, '0']
- [blocks_char_to_float_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_char_to_float_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_char_to_float_1, '0', blocks_delay_0, '0']
- [blocks_delay_0, '0', blocks_sub_xx_0, '1']
- [blocks_delay_0, '0', qtgui_time_sink_x_0, '2']
- [blocks_file_source_0, '0', blocks_packed_to_unpacked_xx_0, '0']
- [blocks_file_source_0, '0', digital_ofdm_carrier_allocator_cvc_0, '0']
- [blocks_file_source_0, '0', virtual_sink_1, '0']
- [blocks_sub_xx_0, '0', qtgui_time_sink_x_0, '1']
- [blocks_unpack_k_bits_bb_0, '0', blocks_char_to_float_1, '0']
- [blocks_unpacked_to_packed_xx_0_0, '0', blocks_file_sink_0, '0']
- [blocks_unpacked_to_packed_xx_0_0_0, '0', blocks_unpacked_to_packed_xx_0_0, '0']
- [digital_cma_equalizer_cc_0, '0', digital_costas_loop_cc_0, '0']
- [digital_constellation_decoder_cb_0, '0', digital_diff_decoder_bb_0, '0']
- [digital_costas_loop_cc_0, '0', digital_constellation_decoder_cb_0, '0']
- [digital_costas_loop_cc_0, '0', qtgui_const_sink_x_0_0, '0']
- [digital_costas_loop_cc_0, '0', qtgui_time_sink_x_2_0, '0']
- [digital_diff_decoder_bb_0, '0', blocks_char_to_float_0, '0']
- [digital_diff_decoder_bb_0, '0', blocks_unpacked_to_packed_xx_0_0_0, '0']
- [digital_ofdm_carrier_allocator_cvc_0, '0', digital_ofdm_cyclic_prefixer_0, '0']
- [digital_ofdm_cyclic_prefixer_0, '0', qtgui_const_sink_x_0, '0']
- [digital_ofdm_cyclic_prefixer_0, '0', qtgui_time_sink_x_2, '0']
- [digital_ofdm_cyclic_prefixer_0, '0', virtual_sink_0, '0']
- [virtual_source_0, '0', digital_cma_equalizer_cc_0, '0']
- [virtual_source_2, '0', blocks_unpack_k_bits_bb_0, '0']

metadata:
  file_format: 1
