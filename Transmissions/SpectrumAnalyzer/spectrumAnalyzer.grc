options:
  parameters:
    author: Javier Acevedo
    copyright: MIT License
    generate_options: qt_gui
    id: spectrum_analyzer
    output_language: python
    title: SpectrumAnalyzer
  states: {}

blocks:
- name: center_freq_trans
  id: variable_qtgui_range
  parameters:
    start: 1.5e9
    step: 1e8
    stop: 3.5e9
    value: 2e9
  states: {}
- name: decimation
  id: variable
  parameters:
    value: '10'
  states: {state: disabled}
- name: decimation
  id: variable_qtgui_range
  parameters:
    start: '5'
    step: '1'
    stop: '20'
    value: '10'
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '100'
    value: '50'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: transition_bw
  id: variable
  parameters:
    value: '1'
  states: {}
- name: analog_sig_source_x_1
  id: analog_sig_source_x
  parameters:
    amp: gain
    freq: center_freq_trans
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: freq_xlating_fft_filter_ccc_0
  id: freq_xlating_fft_filter_ccc
  parameters:
    center_freq: '0'
    decim: '1'
    samp_rate: samp_rate
    taps: firdes.low_pass(1,samp_rate,samp_rate/(2*decimation), transition_bw)
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: center_freq_trans
    fftsize: '2048'
    type: complex
  states: {state: disabled}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: center_freq_trans
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: center_freq_trans
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    size: '2048'
    srate: samp_rate
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: complex
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: center_freq_trans
    dev_addr: addr=192.168.10.200
    gain0: gain/2
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: center_freq_trans
    dev_addr: addr=192.168.10.2
    gain0: '0'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {state: disabled}
- name: uhd_usrp_source_0_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: center_freq_trans
    dev_addr: addr=192.168.10.2
    gain0: '0'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_sig_source_x_1, '0', blocks_throttle_0, '0']
- [analog_sig_source_x_1, '0', qtgui_freq_sink_x_1, '0']
- [analog_sig_source_x_1, '0', qtgui_time_sink_x_0, '0']
- [blocks_throttle_0, '0', uhd_usrp_sink_0, '0']
- [freq_xlating_fft_filter_ccc_0, '0', qtgui_freq_sink_x_0_0, '0']
- [uhd_usrp_source_0, '0', qtgui_freq_sink_x_0, '0']
- [uhd_usrp_source_0_0, '0', freq_xlating_fft_filter_ccc_0, '0']

metadata:
  file_format: 1
