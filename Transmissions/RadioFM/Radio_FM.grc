options:
  parameters:
    author: Javier Acevedo
    copyright: MIT
    generate_options: qt_gui
    id: Radio_FM
    output_language: python
    title: radioFM
  states: {}

blocks:
- name: audio_rate
  id: variable
  parameters:
    value: 20e3
  states: {}
- name: interpolation
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '15'
    value: '4'
  states: {}
- name: samp_rate
  id: variable_qtgui_range
  parameters:
    start: 150e3
    step: 10e3
    stop: 350e3
    value: 250e3
  states: {}
- name: tuning
  id: variable_qtgui_range
  parameters:
    start: 100e6
    step: 1e3
    stop: 6e9
    value: 103.5e6
  states: {}
- name: volumen_Gain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '100'
    value: '65'
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: interpolation
    quad_rate: 192e3
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: QT GUI Plot
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '250000'
    interp: '201600'
    type: ccc
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"TX/RX"'
    center_freq0: tuning
    dev_addr: addr=192.168.10.200
    gain0: volumen_Gain
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_wfm_rcv_0, '0', audio_sink_0, '0']
- [rational_resampler_xxx_0, '0', analog_wfm_rcv_0, '0']
- [uhd_usrp_source_0, '0', qtgui_sink_x_0, '0']
- [uhd_usrp_source_0, '0', rational_resampler_xxx_0, '0']

metadata:
  file_format: 1
